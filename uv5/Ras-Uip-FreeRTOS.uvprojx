# Keil uVision project Ras-Uip-FreeRTOS.uvprojx, settings and files
target STM32F4 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Ras-Uip-FreeRTOS
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\..\Ras-Lib\CMSIS\Include;..\..\Ras-Lib\CMSIS\ST\STM32F4xx\Include;..\..\Ras-Lib\STM32F4xx_StdPeriph_Driver\inc;..\src;..\src\uip\uip;..\src\uip\apps\resolv;..\..\Ras-Lib\FreeRTOS\include;..\..\Ras-Lib\FreeRTOS\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../src/: main.c
  group device
    ../src/: enc28j60.c
  group uip
    ../src/uip/uip/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c
  group uip-app
    ../src/uip/apps/resolv/: resolv.c
    ../src/: tapdev.c tcp-demo.c clock-arch.c
  group FreeRTOS
    ../../Ras-Lib/FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ../../Ras-Lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../../Ras-Lib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group cpu
    ../../Ras-Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_pwr.c
software components: Device:Startup 2.6.0
